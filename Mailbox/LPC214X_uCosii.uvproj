# Keil uVision project LPC214X_uCosii.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC2142 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0xFFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: LPC214X_uCosii +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x40000000 size 0x4000
  scatter file: .\APP\mem_a.scf
  group APP
    ./APP/: target.c main.c IRQ.s Startup.s
  group uCosii
    ./uCosii/: OS_CORE.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C
  group Arm
    ./ARM/: Os_cpu_c.c Os_cpu_a.s
